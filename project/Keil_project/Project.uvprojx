# Keil uVision project Project.uvprojx, settings and files
target GD32F30X_CL (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: GD32F303RE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.1.1.0
  cpu: IROM(0x08000000,0x080000) IRAM(0x20000000,0x010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_CL
  c include: ..\..\Firmware\CMSIS;..\..\Firmware\CMSIS\GD\GD32F30x\Include;..\..\Firmware\GD32F30x_standard_peripheral\Include;..\..\Utilities;..\
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../: gd32f30x_it.c main.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group Peripherals
    ../../Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_cl.s startup_gd32f30x_hd.s startup_gd32f30x_xd.s
  group Utilities
    ../../Utilities/: gd32f303e_eval.c
  group Doc
    ../: readme.txt
  group HardWare
    ../../hardware/ADC_DMA/: ADC_DMA.c
    ../../hardware/UART_DMA/: UART_DMA.c
    ../../hardware/: hardware.h
    ../../hardware/MATH/: sysType.h MyMath.c
    ../../hardware/PWMout/: PWMout.c
    ../../hardware/SPI/: SPI.c
    ../../hardware/PWM_PPM_capture/: PWM_PPM_capture.c
    ../../hardware/TIMER/: Timer.c
  group system
    ../../SYSTEM/TLE5012B/: TLE5012B.c
    ../../SYSTEM/FOCdriver/: FOCdriver.c
    ../../SYSTEM/flash_para/: flash_para.c
    ../../SYSTEM/FOCInterface/: FOCcontrol.c
    ../../SYSTEM/sysTick/: systick.c
target GD32F30X_XD (ARM-ADS)
  device: GD32F303RK GigaDevice
  pack: GigaDevice.GD32F30x_DFP.1.1.0
  cpu: IROM(0x08000000,0x0300000) IRAM(0x20000000,0x018000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_XD
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x18000
target GD32F30X_HD (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: GD32F303RE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.1.1.0
  cpu: as above
  output: GD303_Gimble +hex
  c flags: oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c misc: --gnu
  c include: ..\..\Firmware\CMSIS;..\..\Firmware\CMSIS\GD\GD32F30x\Include;..\..\Firmware\GD32F30x_standard_peripheral\Include;..\..\Utilities;..\;..\..\hardware;..\..\hardware\ADC_DMA;..\..\hardware\GPIO;..\..\hardware\I2C;..\..\hardware\MATH;..\..\hardware\PWMout;..\..\hardware\PWM_PPM_capture;..\..\hardware\SPI;..\..\hardware\TIMER;..\..\hardware\UART_DMA;..\..\SYSTEM\FOCdriver;..\..\SYSTEM\TLE5012B;..\..\SYSTEM\flash_para;..\..\hardware\MATH;..\..\SYSTEM\FOCInterface;..\..\SYSTEM\sysTick
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
